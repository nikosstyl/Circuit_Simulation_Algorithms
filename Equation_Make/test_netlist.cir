I1 0 1 2
L1 1 3 0.1e-6
R1 1 2 10
C1 0 2 1e-3
R2 3 0 10e3
V1 3 0 2
